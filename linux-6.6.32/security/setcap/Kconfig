## linux-6.6.32/security/setcap/Kconfig
```kconfig
config SETCAP
    bool "Setting global capabilities"
    default n
    help
        "Disable or enable for all users given system capabilities"
```
